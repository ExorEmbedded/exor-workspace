inherit core-image-exorint

IMAGE_INSTALL += "base-configos"
