inherit core-image-exorint-min

IMAGE_INSTALL += "base-mainos"
