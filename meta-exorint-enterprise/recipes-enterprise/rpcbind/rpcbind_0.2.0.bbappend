
INITSCRIPT_PARAMS_wu16 = "start 12 5 . start 32 0 6 . stop 81 1 ."
