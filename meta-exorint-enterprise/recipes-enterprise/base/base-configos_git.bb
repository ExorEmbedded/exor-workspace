require base.inc

export CONFIG = "configos"

RCONFLICTS_${PN} = "base-mainos"
