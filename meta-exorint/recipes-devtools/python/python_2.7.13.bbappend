# Add missing file to core package
FILES_${PN}-core += "${libdir}/python${PYTHON_MAJMIN}/_sysconfigdata.py*"
