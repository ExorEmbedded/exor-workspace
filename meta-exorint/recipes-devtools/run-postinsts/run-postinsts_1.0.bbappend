
INITSCRIPT_NAME = "run-postinsts"
INITSCRIPT_PARAMS_wu16 = "start 90 S ."

