FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PR := "${PR}.x6"

INITSCRIPT_PARAMS = "defaults 86 4"
