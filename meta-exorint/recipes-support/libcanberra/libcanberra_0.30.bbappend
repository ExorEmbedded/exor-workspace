# Use gtk2, not gtk3
PACKAGECONFIG = "gtk"
