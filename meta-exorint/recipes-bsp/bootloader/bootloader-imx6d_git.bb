UBOOT_MACHINE ?= "mx6dl_usom_config"
TAGNAME = "B03D"

require bootloader-imx.inc
