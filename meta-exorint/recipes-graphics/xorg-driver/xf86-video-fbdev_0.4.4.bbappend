FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += " file://removed_fb_blank_init.patch"
