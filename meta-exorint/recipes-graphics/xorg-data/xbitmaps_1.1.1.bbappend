# Fixes install of complementary packages in the SDK
ALLOW_EMPTY_${PN} = "1"
