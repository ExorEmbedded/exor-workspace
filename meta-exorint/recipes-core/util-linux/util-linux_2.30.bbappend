do_install_append() {
	rm -f ${D}${base_sbindir}/fsck*
}
