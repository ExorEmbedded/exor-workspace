FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"
PR := "${PR}.x0"

