PR := "${PR}.x0"

# avoid kernel-vmlinux dependency
RRECOMMENDS_${PN} = ""
