CXXFLAGS_append = " -fpermissive -std=gnu++98"
