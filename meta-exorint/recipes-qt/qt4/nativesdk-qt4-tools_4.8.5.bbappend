# Disable .pch files generati which may cause build issues
EXTRA_OECONF += " -no-pch"
