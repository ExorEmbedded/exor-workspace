PACKAGECONFIG = "readline"
